# Keil uVision project DS18B20 printf输出.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 工程模板 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\user;.\APP;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\APP\LED;.\APP\beep;.\APP\systick;.\APP\按键;.\APP\数码管;.\APP\外部中断;.\APP\定时器;.\APP\PWM;.\APP\232串口;.\APP\printf;.\APP\IIC(24C02);.\APP\AT24Cxx;.\APP\DS18B20
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./user/: main.c stm32f10x_it.c public.c
  group cmsis
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group startup
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group stdperiph_Drive
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c misc.c stm32f10x_tim.c stm32f10x_usart.c
  group APP
    ./APP/LED/: led.c
    ./APP/beep/: beep.c
    ./APP/systick/: systick.c
    ./APP/按键/: key.c
    ./APP/232串口/: usart.c
    ./APP/定时器/: time.c
    ./APP/数码管/: smg.c
    ./APP/外部中断/: exti.c
    ./APP/PWM/: pwm.c
    ./APP/printf/: printf.c
    ./APP/IIC(24C02)/: iic.c
    ./APP/AT24Cxx/: AT24Cxx.c
    ./APP/DS18B20/: ds18b20.c
