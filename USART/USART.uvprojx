# Keil uVision project USART.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\user;.\APP;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\APP\LED;.\APP\BEEP;.\APP\SYSTICK;.\APP\BUTTON;.\APP\DIGITAL;.\APP\external_interrupt;.\APP\timer;.\APP\pwm;.\APP\usart232
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./user/: main.c stm32f10x_it.c public.c
  group cmsis
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group StartUp
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group stdperiph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c misc.c stm32f10x_tim.c stm32f10x_usart.c
  group APP
    ./APP/LED/: led.c
    ./APP/BEEP/: beep.c
    ./APP/SYSTICK/: systick.c
    ./APP/BUTTON/: key.c
    ./APP/DIGITAL/: digital.c
    ./APP/external_interrupt/: ext_in.c
    ./APP/timer/: timer.c
    ./APP/pwm/: pwm.c
    ./APP/usart232/: usart232.c
